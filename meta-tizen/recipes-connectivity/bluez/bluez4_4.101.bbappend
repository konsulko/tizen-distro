FILES_${PN} += "/usr/lib/udev/hid2hci"