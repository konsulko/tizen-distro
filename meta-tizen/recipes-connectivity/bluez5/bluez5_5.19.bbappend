do_install_append() {
 rm -fr ${D}/usr/lib/udev/hid2hci
}