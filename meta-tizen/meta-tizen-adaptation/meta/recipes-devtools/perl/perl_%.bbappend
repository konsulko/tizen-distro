SECTION = "Development/Perl"
SRPM_IS_LIB = "perl-lib"
