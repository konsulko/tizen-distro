EXTRA_OECONF_class-native += "--with-serf=no"

