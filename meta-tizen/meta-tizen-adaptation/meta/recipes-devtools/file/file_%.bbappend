SECTION = "Base/Utilities"
SRPM_IS_LIB = "libmagic"
