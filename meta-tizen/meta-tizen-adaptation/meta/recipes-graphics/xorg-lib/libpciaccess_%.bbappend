SECTION = "Base/Device Management"
SRPM_IS_LIB = "${PN}"
