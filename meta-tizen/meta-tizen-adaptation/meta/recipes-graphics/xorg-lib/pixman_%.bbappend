SECTION = "Graphics & UI Framework/Libraries"
SRPM_IS_LIB = "${PN}"
