SECTION = "Graphics/Libraries"

PACKAGECONFIG_append = " egl "
PACKAGECONFIG_append = " glesv2 "
