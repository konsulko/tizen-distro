# Use bluez5 instead of bluez4
RDEPENDS_packagegroup-base-bluetooth_remove = "bluez4"
RDEPENDS_packagegroup-base-bluetooth += "bluez5"
