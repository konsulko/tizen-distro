SECTION = "Development/Tools"
SRPM_IS_LIB = "${PN}"
