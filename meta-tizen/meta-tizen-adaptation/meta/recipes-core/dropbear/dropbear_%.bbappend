SECTION = "Security/Network"

#PAM_SRC_URI = ""
PAM_PLUGINS = "libpam-runtime"

