SECTION = "Base/Toolchain"
SRPM_IS_LIB = "${PN}"
