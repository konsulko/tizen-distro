SECTION = "Connectivity/NFC"
