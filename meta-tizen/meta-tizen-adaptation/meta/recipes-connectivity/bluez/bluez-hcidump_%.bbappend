# Use bluez5 instead of bluez4
DEPENDS_remove = "bluez4"
DEPENDS += "bluez5"
