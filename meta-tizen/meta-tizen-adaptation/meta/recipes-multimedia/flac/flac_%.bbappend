SECTION = "Multimedia/Audio"
SRPM_IS_LIB = "libflac"
SRPM_IS_LIB = "libflac++"
