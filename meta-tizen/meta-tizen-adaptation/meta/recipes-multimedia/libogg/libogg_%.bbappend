SECTION = "Multimedia/Audio"
SRPM_IS_LIB = "${PN}"
