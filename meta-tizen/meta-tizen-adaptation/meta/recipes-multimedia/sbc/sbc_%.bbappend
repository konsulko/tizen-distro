SECTION = "Multimedia/Utilities"
SRPM_IS_LIB = "${PN}"
