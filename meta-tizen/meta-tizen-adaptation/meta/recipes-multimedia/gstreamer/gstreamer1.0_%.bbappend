SECTION = "Multimedia/Service"

EXTRA_OECONF += "--disable-examples --disable-tests"

