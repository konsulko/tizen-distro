SECTION = "Multimedia/Libraries"
SRPM_IS_LIB = "${PN}"
