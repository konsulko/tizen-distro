SECTION = "Application Framework/Database"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://Fix_JOURNALMODE_PERSIST.patch"