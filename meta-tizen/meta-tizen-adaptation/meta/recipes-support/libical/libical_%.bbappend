SECTION = "Social & Content/Libraries"
SRPM_IS_LIB = "${PN}"
