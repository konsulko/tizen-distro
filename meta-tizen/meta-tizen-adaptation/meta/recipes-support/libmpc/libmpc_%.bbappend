SECTION = "Development/Toolchain"
SRPM_IS_LIB = "${PN}"
