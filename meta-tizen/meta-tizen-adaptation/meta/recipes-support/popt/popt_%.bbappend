SECTION = "Base/Libraries"
SRPM_IS_LIB = "${PN}"
