SECTION = "Development/Libraries"
SRPM_IS_LIB = "${PN}"
