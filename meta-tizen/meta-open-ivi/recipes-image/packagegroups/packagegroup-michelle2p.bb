SUMMARY = "Michelle 2 Plus Specific Packages"
DESCRIPTION = "Michelle 2 Plus Specific Packages"
LICENSE = "Apache-2.0"

inherit packagegroup

PACKAGES = "\
	packagegroup-michelle2p\
	"

RDEPENDS_packagegroup-michelle2p = " \
	michelle2p-supervisor \
	"
