FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://dbus-DBusMessage-add-support-for-custom-marshaling.patch"
