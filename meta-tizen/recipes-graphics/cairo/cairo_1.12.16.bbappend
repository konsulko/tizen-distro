PACKAGECONFIG_append = " egl "
PACKAGECONFIG_append = " glesv2 "
