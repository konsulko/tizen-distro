require testkit-stub.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/test/tools/testkit-stub;protocol=ssh;tag=3a9b03424e239e72b3ff30a5cf9753c8e0de687f;nobranch=1"

