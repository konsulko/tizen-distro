require swup.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/swup;protocol=ssh;tag=d00de0eb54070ce199198ca0298da78339eb18ac;nobranch=1"

