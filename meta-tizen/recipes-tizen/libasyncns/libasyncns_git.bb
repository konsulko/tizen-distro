require libasyncns.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/libasyncns;protocol=ssh;tag=383115e0a8ad9456e9a1f08e6fb1b9d33740b055;nobranch=1"

