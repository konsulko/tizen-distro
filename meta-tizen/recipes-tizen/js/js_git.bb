require js.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/js;protocol=ssh;tag=51aad82a2b47cf252946883bf0d04894b283a823;nobranch=1"

