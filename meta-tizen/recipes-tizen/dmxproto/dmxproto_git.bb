require dmxproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/dmxproto;protocol=ssh;tag=1a7a30575cce449a856a1d96c3337debe05cf205;nobranch=1"

