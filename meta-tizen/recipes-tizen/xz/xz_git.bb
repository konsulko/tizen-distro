require xz.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/xz;protocol=ssh;tag=ef6a87c1cb8d75760f291c6d2c803f5c554c0512;nobranch=1"

