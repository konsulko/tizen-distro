require renderproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/renderproto;protocol=ssh;tag=29b3c24d1d4288edc923e0d1d3f87831d0a23a47;nobranch=1"

