require qtquickcontrols.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/qtquickcontrols;protocol=ssh;tag=99bc788c3b47a7c722cfe9bd6e9023c32c0c0c42;nobranch=1"

