require dash.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/dash;protocol=ssh;tag=f5005a788340f3d8b5eb7f863401404dd36e3fcc;nobranch=1"

