require shared-mime-info.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/shared-mime-info;protocol=ssh;tag=666f2a09020e48b49a92221fb728f18e03177b8a;nobranch=1"

