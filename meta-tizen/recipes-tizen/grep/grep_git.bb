require grep.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/grep;protocol=ssh;tag=80290130fe194007fa82b653c98159dc63bc937a;nobranch=1"

