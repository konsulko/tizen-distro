require call.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/api/call;protocol=ssh;tag=35ff9d2b18ef017d039415dd06e17c2043a63d9c;nobranch=1"

