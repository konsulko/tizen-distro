require bootchart.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/bootchart;protocol=ssh;tag=e8d33ffb9edcb2081ef318c7695e9c752c782f95;nobranch=1"

