require python-iniparse.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python-iniparse;protocol=ssh;tag=484ca3dca436e198445bf9f2264a3db0451b07ed;nobranch=1"

