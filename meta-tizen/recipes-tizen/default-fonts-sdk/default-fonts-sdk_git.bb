require default-fonts-sdk.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/graphics/default-fonts-sdk;protocol=ssh;tag=66643c76f4cc023b9b52d9dd65a0d8e81539f67c;nobranch=1"

