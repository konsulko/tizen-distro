require python.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python;protocol=ssh;tag=17609363aeba2937526f67242f920ffffe0ba0f6;nobranch=1"

