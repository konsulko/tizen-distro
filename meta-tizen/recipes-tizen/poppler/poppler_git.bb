require poppler.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/poppler;protocol=ssh;tag=d8c217cdb0fb6943e796c50f834bbbdd74cbcd21;nobranch=1"

