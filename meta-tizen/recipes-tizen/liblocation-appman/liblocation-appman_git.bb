require liblocation-appman.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/location/liblocation-appman;protocol=ssh;tag=0ebce4e1b4bf76e3b78b71d558a570dbeae17d18;nobranch=1"

