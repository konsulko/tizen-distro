require cscope.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cscope;protocol=ssh;tag=f9e72a9ab56627f5b3b8c811e0bc9d4ec23073c4;nobranch=1"

