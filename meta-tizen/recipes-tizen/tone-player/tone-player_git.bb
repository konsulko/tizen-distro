require tone-player.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/api/tone-player;protocol=ssh;tag=615d04b7fefe830fbfcc5f98cd06fbcd7cf9968c;nobranch=1"

