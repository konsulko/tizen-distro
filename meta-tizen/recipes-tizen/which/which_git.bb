require which.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/which;protocol=ssh;tag=7ead7429bbda9e741dabfdd49f0a6094e22c3095;nobranch=1"

