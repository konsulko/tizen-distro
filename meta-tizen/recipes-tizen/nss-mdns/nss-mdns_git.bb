require nss-mdns.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/nss-mdns;protocol=ssh;tag=101c6f0f62516a61383fb0fbc669fe16bca2b1f1;nobranch=1"

