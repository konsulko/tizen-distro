require hunspell.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/hunspell;protocol=ssh;tag=4da2785cfefb5db2c38fc83b75f581289690bab2;nobranch=1"

