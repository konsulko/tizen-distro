require remix.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/remix;protocol=ssh;tag=bcfdce550685004fdfbca004c5efcaf13c76db21;nobranch=1"

