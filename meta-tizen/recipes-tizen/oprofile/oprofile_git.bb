require oprofile.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/oprofile;protocol=ssh;tag=c17ba13925827d6d098185dc07ed3f06801ea76b;nobranch=1"

