require pixman.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/pixman;protocol=ssh;tag=339ed7f5530179529970fb87a143789ce88e338b;nobranch=1"

