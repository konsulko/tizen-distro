require uw-imap-toolkit.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/uw-imap-toolkit;protocol=ssh;tag=3f209322194c8c7dad1c21233b4b08add5375876;nobranch=1"

