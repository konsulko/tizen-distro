require tcl.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/tcl;protocol=ssh;tag=0a587c06347b735c2e0aa74987c7000eb0019b6d;nobranch=1"

