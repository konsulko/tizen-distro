require icecream.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/icecream;protocol=ssh;tag=f865c8387b8b93115c2b0d3c0d67619cd9ef6a1e;nobranch=1"

