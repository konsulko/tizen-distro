require zlib.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/zlib;protocol=ssh;tag=653cb2d2fa53c43caa5b531d0dbbf76a3c6600f2;nobranch=1"

