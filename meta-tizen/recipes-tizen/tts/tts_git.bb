require tts.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/uifw/tts;protocol=ssh;tag=22a52fb17af7d15b13c866a0cc034363a6d393cf;nobranch=1"

