require GUPnP.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/profile/ivi/GUPnP;protocol=ssh;tag=c0a3c5b934b997cf4bba32b3880a0b24f287bd12;nobranch=1"

