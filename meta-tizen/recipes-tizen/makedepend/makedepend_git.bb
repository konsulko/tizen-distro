require makedepend.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/makedepend;protocol=ssh;tag=6144ee81672046e8aa2943ca9057c3ceb48faa42;nobranch=1"

