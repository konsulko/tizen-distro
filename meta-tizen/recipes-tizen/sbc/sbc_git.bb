require sbc.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/sbc;protocol=ssh;tag=0994e77d249446fe97d4cdd370fbeb2d53b7531b;nobranch=1"

