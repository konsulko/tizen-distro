require deltarpm.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/deltarpm;protocol=ssh;tag=f022dc53010190e5810d6292730866f99a437754;nobranch=1"

