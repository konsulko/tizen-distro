require protobuf.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/protobuf;protocol=ssh;tag=3ba01dce9f0d666ccbd87bf4748186fee2f0423d;nobranch=1"

