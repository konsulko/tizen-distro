require atk.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/atk;protocol=ssh;tag=f1e8a64fa55b1a50b89a70fb177cb0849116d30e;nobranch=1"

