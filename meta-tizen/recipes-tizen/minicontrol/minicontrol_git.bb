require minicontrol.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/apps/core/preloaded/minicontrol;protocol=ssh;tag=3104d9f816d8b240b149bcf0653e7cf7d74bd30a;nobranch=1"

