require gdb.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/gdb;protocol=ssh;tag=02e2d9b41d107eba4e491ec4e5053d6b16b8ebd0;nobranch=1"

