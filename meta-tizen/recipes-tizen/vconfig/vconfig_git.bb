require vconfig.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/vconfig;protocol=ssh;tag=c731d4716a6d500758e6dfffa0e3f3764466702a;nobranch=1"

