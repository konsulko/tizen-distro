require libhaptic.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/system/libhaptic;protocol=ssh;tag=f231283973654cf74742eb4f27e9baca5cb575ac;nobranch=1"

