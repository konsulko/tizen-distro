require isl.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/isl;protocol=ssh;tag=c5a002b518cfc72c60960a740bf4c443aba27ca3;nobranch=1"

