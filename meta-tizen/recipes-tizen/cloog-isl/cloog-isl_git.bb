require cloog-isl.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cloog-isl;protocol=ssh;tag=764b7692a8773390e6734571b07f74ffa43155d1;nobranch=1"

