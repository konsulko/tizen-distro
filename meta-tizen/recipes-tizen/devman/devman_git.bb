require devman.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/system/devman;protocol=ssh;tag=4957252a7971ba6d952ea23f96d1e46da507339f;nobranch=1"

