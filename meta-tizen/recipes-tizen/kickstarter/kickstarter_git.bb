require kickstarter.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/kickstarter;protocol=ssh;tag=4b01601cd2d404d4d72a2399909fb8de5f5bc8e9;nobranch=1"

