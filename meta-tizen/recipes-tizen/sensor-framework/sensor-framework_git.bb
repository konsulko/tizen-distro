require sensor-framework.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/system/sensor-framework;protocol=ssh;tag=71bcf8ea1048dd83b4a913934f424bfd922d4af5;nobranch=1"

