require perl-YAML.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/perl-YAML;protocol=ssh;tag=bff6ca1ce847b306bd6c96b7c25e9615bab93b24;nobranch=1"

