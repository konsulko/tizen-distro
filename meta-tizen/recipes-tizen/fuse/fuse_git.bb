require fuse.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/fuse;protocol=ssh;tag=d30427eee40565e61f83c05fdc31e0857b144152;nobranch=1"

