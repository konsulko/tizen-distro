require libmm-log.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/multimedia/libmm-log;protocol=ssh;tag=a62f929c6e3c7e83e53d401cfd082b60d5af42cd;nobranch=1"

