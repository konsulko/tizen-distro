require SDL.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/SDL;protocol=ssh;tag=cb1727955c8723bdb9538fa77b5f5219c99cfcec;nobranch=1"

