require less.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/less;protocol=ssh;tag=b15e4e4697c92885433b7bf711ef9b815baa0a5b;nobranch=1"

