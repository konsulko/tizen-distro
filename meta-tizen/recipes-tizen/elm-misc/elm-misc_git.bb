require elm-misc.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/uifw/elm-misc;protocol=ssh;tag=1d95f6c7f4bff23480458490ca9260518294957f;nobranch=1"

