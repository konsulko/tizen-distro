require xdelta1.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/xdelta1;protocol=ssh;tag=346b70280c8234a327a761e52610355628427341;nobranch=1"

