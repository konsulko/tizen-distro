require mpc.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/mpc;protocol=ssh;tag=09df21db11c471382a1832c73fcecbd54ca068fa;nobranch=1"

