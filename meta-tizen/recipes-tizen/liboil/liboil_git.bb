require liboil.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/liboil;protocol=ssh;tag=55065d23d2c206575a6c5a0dab12a80a673d72e4;nobranch=1"

