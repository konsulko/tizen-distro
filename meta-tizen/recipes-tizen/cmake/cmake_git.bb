require cmake.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cmake;protocol=ssh;tag=d6f47f30d42735292f96cda03246e83e1a07455b;nobranch=1"

