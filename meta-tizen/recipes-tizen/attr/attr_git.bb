require attr.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/attr;protocol=ssh;tag=91390ab74d45828b5e1f33656f5bd994d9277f1e;nobranch=1"

