require screen.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/screen;protocol=ssh;tag=402f139002bb66fc7d9f01b657e750c156bc2ab2;nobranch=1"

