require data-router.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/connectivity/data-router;protocol=ssh;tag=87f0698e4722cbb75b3c9c3b7323551d9bcb2af1;nobranch=1"

