require cloog.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cloog;protocol=ssh;tag=7fbea83463ba553729f60cc26946af0a7b41eafd;nobranch=1"

