require freealut.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/freealut;protocol=ssh;tag=add09c7d4378122b97259e660029f9104b52a172;nobranch=1"

