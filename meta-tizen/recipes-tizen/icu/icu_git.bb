require icu.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/icu;protocol=ssh;tag=9e09552e2a134315a28da632c56531afa9a2b3ae;nobranch=1"

