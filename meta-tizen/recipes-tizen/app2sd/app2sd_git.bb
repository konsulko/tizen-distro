require app2sd.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/appfw/app2sd;protocol=ssh;tag=454b16564383b40ddf0b7591423bb633fdfb6d2e;nobranch=1"

