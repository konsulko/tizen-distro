require build.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/build;protocol=ssh;tag=a158adee9d5edee09efd8eeb2db92b50a10c2ddb;nobranch=1"

