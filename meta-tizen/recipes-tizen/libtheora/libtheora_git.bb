require libtheora.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/libtheora;protocol=ssh;tag=f80495726b502d2bd4423443aa645f86c7083690;nobranch=1"

