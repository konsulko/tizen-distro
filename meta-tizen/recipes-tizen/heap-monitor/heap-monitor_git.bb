require heap-monitor.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/framework/web/heap-monitor;protocol=ssh;tag=d41e35de4036c319289f2dc34262ab7f37ccfbfd;nobranch=1"

