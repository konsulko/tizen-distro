require gzip.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/gzip;protocol=ssh;tag=f6b2c04d88d9b8111eaa953b1d3166d521fcb6c3;nobranch=1"

