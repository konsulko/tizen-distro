require python-edje.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python-edje;protocol=ssh;tag=4f671dd80c45cd7da1aa942ffe3f4aa9849c0323;nobranch=1"

