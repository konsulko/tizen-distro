require pbzip2.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/pbzip2;protocol=ssh;tag=b5f73dfa628887a6646cdf1f5ef259b7e87cd83d;nobranch=1"

