require compositeproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/compositeproto;protocol=ssh;tag=e8c64e0d2d57ad2eb014866b5ca47fb8cb1e032c;nobranch=1"

