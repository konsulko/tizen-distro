require giflib.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/giflib;protocol=ssh;tag=e9c36cad490cec9af8089ec0b913c617e67ba524;nobranch=1"

