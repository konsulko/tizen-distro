require xtrans.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/xtrans;protocol=ssh;tag=a31becf87a863e0975ef99f706126dfb67ddd57f;nobranch=1"

