require flac.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/flac;protocol=ssh;tag=cc1d2e5db80c2c5a607176c4dcb5895000d7b5f1;nobranch=1"

