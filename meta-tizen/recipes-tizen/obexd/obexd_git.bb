require obexd.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/obexd;protocol=ssh;tag=6c58bd7f4ad00916eaf1f482bad1007ab597d653;nobranch=1"

