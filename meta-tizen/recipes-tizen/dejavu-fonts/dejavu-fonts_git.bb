require dejavu-fonts.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/dejavu-fonts;protocol=ssh;tag=b03f82c16c070c29537548c938731e91d7c58db8;nobranch=1"

