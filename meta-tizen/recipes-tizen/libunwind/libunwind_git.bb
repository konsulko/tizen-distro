require libunwind.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/libunwind;protocol=ssh;tag=dbbc2ee536ad42d83b2e2c0ed26f31b4f3dbff6c;nobranch=1"

