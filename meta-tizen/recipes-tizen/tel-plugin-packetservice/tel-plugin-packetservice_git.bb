require tel-plugin-packetservice.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/telephony/tel-plugin-packetservice;protocol=ssh;tag=767294d4521eb4f4f5d62e7233e7984ef862a756;nobranch=1"

