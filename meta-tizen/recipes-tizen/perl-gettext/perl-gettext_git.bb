require perl-gettext.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/perl-gettext;protocol=ssh;tag=edbae5e768668b549e1ed09c89bc8b47b67a0f2d;nobranch=1"

