require libXau.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/libXau;protocol=ssh;tag=1009aced5f13c9fd1f2436bad897dc54ca735fde;nobranch=1"

