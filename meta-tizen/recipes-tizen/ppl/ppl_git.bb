require ppl.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/ppl;protocol=ssh;tag=a0aad599d383f3ebfc6db0eef4101050cb00b9d5;nobranch=1"

