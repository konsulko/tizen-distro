require ed.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/ed;protocol=ssh;tag=2ba5796fce411581d0f0a0b1339e18537a3626b7;nobranch=1"

