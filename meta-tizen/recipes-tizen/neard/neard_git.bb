require neard.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/neard;protocol=ssh;tag=98c95b675a8fb39ae817bd1938f8bc2465c15f19;nobranch=1"

