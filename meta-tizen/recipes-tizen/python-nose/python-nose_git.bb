require python-nose.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python-nose;protocol=ssh;tag=e20b3d3d2b78c099b2a78e6298c18473a51b468a;nobranch=1"

