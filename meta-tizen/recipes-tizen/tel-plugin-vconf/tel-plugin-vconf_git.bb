require tel-plugin-vconf.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/telephony/tel-plugin-vconf;protocol=ssh;tag=9e4d6a6ce3c7da4a7cec39510e682539c6383ac3;nobranch=1"

