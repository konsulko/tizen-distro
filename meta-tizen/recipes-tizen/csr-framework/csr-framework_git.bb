require csr-framework.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/csr-framework;protocol=ssh;tag=4009df71f3dbc03d45c73d06ffbf84b3a332a1b5;nobranch=1"

