require cups.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cups;protocol=ssh;tag=542afd43930fc50ce563efe8e0d8ff78c77416e7;nobranch=1"

