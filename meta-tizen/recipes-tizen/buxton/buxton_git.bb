require buxton.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/buxton;protocol=ssh;tag=ec046d187be6ea2a6349234cf141c73ef4c2b598;nobranch=1"

