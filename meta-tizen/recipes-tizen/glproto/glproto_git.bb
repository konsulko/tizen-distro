require glproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/glproto;protocol=ssh;tag=c134dbd962bf45f0ed48083d89961649f8ef81d0;nobranch=1"

