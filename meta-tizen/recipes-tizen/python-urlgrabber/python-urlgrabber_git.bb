require python-urlgrabber.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python-urlgrabber;protocol=ssh;tag=0acddc325ed11e1d6cbed796a0a4adb4bdb67412;nobranch=1"

