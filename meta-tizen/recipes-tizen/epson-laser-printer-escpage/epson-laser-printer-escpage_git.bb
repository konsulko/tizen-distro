require epson-laser-printer-escpage.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/epson-laser-printer-escpage;protocol=ssh;tag=1f33dcf8e17f2cc65eeb5a9f885da88e69345893;nobranch=1"

