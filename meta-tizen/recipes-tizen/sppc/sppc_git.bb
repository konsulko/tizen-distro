require sppc.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/appfw/sppc;protocol=ssh;tag=a3cfb75871c9bccd1edc98903296f223e2537521;nobranch=1"

