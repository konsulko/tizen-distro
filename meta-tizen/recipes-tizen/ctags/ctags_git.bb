require ctags.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/ctags;protocol=ssh;tag=fdf26526d4d0661fb1afc6b3d18b91d926222aa1;nobranch=1"

