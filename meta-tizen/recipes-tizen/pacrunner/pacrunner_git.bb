require pacrunner.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/pacrunner;protocol=ssh;tag=21cfe915c85b24f98678e19c979cc61c49a0e159;nobranch=1"

