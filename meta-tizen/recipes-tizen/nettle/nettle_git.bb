require nettle.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/nettle;protocol=ssh;tag=81297f25ff4d7e7bf28e6fc95d9250474b7805a7;nobranch=1"

