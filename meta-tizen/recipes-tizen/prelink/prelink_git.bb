require prelink.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/prelink;protocol=ssh;tag=669de443af1abe1b7d7d7745451a32d0987fe4d1;nobranch=1"

