require wav-player.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/api/wav-player;protocol=ssh;tag=4a4da55395bef33c87ea8a0704d19dda43073cb1;nobranch=1"

