require xf86bigfontproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/xf86bigfontproto;protocol=ssh;tag=24933985e96eefd3142294d3c56f6d035d0d8dc2;nobranch=1"

