require pwdutils.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/pwdutils;protocol=ssh;tag=d194a26d170ea0b84a6488f6b234d1092280c4b4;nobranch=1"

