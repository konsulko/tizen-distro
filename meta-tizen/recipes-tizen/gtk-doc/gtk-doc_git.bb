require gtk-doc.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/gtk-doc;protocol=ssh;tag=280210cae6389e64b42a43bf70eafc1c6a490084;nobranch=1"

