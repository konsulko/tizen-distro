require cantarell-fonts.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cantarell-fonts;protocol=ssh;tag=a6286586ab10ee724f2e5583c625f81c6ecf8e38;nobranch=1"

