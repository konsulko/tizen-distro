require rng-tools.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/rng-tools;protocol=ssh;tag=06763962209d71b8d6e48e1c73c643b10636fb73;nobranch=1"

