require enchant.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/enchant;protocol=ssh;tag=f7290c9bbb4eeca3770e6da076bbb62cb270d9a0;nobranch=1"

