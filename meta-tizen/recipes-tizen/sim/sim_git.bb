require sim.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/api/sim;protocol=ssh;tag=c1be96eb809b36b5886fcdc662c538ab62fac990;nobranch=1"

