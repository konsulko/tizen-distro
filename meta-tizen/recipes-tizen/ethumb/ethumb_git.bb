require ethumb.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/ethumb;protocol=ssh;tag=b6e90eaf24d6e70daf3f1ad81e6161f768705d63;nobranch=1"

