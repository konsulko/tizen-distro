require tel-plugin-indicator.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/telephony/tel-plugin-indicator;protocol=ssh;tag=8da53bc13f7ca491b7e8e1976d5aa4686bf594ad;nobranch=1"

