require acl.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/acl;protocol=ssh;tag=eaa0bb85502a1b08ad704026b85846c6ebadef2f;nobranch=1"

