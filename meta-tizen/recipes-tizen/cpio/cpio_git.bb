require cpio.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cpio;protocol=ssh;tag=de4710ca16b9e425e899fc310ec7a6204a119e9d;nobranch=1"

