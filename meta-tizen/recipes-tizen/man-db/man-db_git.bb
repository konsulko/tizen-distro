require man-db.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/man-db;protocol=ssh;tag=c521d788537b4186afd5ab2f108f424a57b97aa4;nobranch=1"

