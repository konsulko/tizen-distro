require stt.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/uifw/stt;protocol=ssh;tag=1ab475bb3d3b7ce0e207c68716822c9e6208e097;nobranch=1"

