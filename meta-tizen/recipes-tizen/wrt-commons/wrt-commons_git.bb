require wrt-commons.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/framework/web/wrt-commons;protocol=ssh;tag=a560386f384df90907150b436655098361ba6cef;nobranch=1"

