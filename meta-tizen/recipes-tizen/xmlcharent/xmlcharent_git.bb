require xmlcharent.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/xmlcharent;protocol=ssh;tag=0489c3ebdd9b3501928110dc6549bfe26efd3b99;nobranch=1"

