require randrproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/randrproto;protocol=ssh;tag=d12d69687b89345ec24cd3f5aa6a40445e8aef2c;nobranch=1"

