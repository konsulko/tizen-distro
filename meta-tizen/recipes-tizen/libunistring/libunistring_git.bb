require libunistring.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/libunistring;protocol=ssh;tag=b034570bc29819e381b4e1b0c1675f753c246346;nobranch=1"

