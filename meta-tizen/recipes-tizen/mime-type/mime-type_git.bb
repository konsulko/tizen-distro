require mime-type.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/api/mime-type;protocol=ssh;tag=10b842377825d94b4d0367d60dc3f7586274a663;nobranch=1"

