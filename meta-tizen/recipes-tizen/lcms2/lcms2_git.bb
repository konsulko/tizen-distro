require lcms2.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/lcms2;protocol=ssh;tag=d8c610099fe10862394b5fece5df227df9be1ca0;nobranch=1"

