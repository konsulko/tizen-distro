require xf86dgaproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/xf86dgaproto;protocol=ssh;tag=379e2c36919eea6ee4c3e464fb7b59010d1b2cb4;nobranch=1"

