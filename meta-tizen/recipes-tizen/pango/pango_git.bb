require pango.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/pango;protocol=ssh;tag=3e3d02e93fa86733b9185c7677dc25a61c9afd32;nobranch=1"

