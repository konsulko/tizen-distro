require perl-XML-Twig.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/perl-XML-Twig;protocol=ssh;tag=58c6648c360fbd0dbc77e7eaecf931863988f8ec;nobranch=1"

