require patch.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/patch;protocol=ssh;tag=b23e82b945254b1734a503989403b3bc706c9ede;nobranch=1"

