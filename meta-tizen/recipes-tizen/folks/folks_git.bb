require folks.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/folks;protocol=ssh;tag=716e4ef1bbd2b98988ce849a9a6c6b5784d537cc;nobranch=1"

