require python-Cheetah.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python-Cheetah;protocol=ssh;tag=233a54fa2616d3b19b7559e1a77ed64163fcbcf3;nobranch=1"

