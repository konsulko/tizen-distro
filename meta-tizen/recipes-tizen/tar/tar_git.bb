require tar.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/tar;protocol=ssh;tag=c220badf2d9b55175284a67c8f4156fb5a5200d7;nobranch=1"

