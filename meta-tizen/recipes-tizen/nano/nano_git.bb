require nano.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/nano;protocol=ssh;tag=512287cadcc31d9bc0a5702ff4ca5aa5155d7fd2;nobranch=1"

