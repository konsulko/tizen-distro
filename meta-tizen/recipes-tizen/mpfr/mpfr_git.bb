require mpfr.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/mpfr;protocol=ssh;tag=06e7bd566fbab49954fce7a3b41a113221b65e45;nobranch=1"

