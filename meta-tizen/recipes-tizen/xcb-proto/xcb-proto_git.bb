require xcb-proto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/xcb-proto;protocol=ssh;tag=0ac4665e4869874f94154e0c5a653aa4f446199c;nobranch=1"

