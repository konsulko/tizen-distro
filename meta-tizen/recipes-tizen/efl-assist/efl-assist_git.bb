require efl-assist.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/uifw/efl-assist;protocol=ssh;tag=2659fedd5554aa32ddc72c3ff4c7a11c759cfd36;nobranch=1"

