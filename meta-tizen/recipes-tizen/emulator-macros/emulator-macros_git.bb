require emulator-macros.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/emulator-macros;protocol=ssh;tag=cfa44635164265eb9a06a9ec13642aadfa3d5b69;nobranch=1"

