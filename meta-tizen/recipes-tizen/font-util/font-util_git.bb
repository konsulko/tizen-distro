require font-util.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/font-util;protocol=ssh;tag=0c7982d298506455d395d999cd0c597aeb3d8a4a;nobranch=1"

