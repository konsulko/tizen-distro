require gccmakedep.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/gccmakedep;protocol=ssh;tag=9c7ebd9444b1c12e27cef6c7e7d4566a05488de2;nobranch=1"

