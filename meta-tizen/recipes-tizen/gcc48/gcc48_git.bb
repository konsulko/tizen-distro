require gcc48.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/gcc48;protocol=ssh;tag=135d550e26f7e477fff0c48f94ddc38cfa8d3028;nobranch=1"

