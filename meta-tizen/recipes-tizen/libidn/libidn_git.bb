require libidn.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/libidn;protocol=ssh;tag=74e8b53e1da2f136d54f937a7a81ee87417943d3;nobranch=1"

