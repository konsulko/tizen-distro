require uim.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/uim;protocol=ssh;tag=6ab87ec8436c79afbb8aca7a7c8ab9eab73858fe;nobranch=1"

