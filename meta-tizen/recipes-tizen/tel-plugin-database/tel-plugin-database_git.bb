require tel-plugin-database.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/telephony/tel-plugin-database;protocol=ssh;tag=ef80da04702f90ae61315f4a05050dbc5fe0fa60;nobranch=1"

