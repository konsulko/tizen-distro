require cdrkit.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cdrkit;protocol=ssh;tag=d206d98f6f6be40156d9f94eda8196dc307dedbe;nobranch=1"

