require lzo.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/lzo;protocol=ssh;tag=19df7de33daefcf660df1e23553ef270229e4203;nobranch=1"

