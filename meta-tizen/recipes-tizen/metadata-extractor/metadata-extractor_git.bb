require metadata-extractor.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/api/metadata-extractor;protocol=ssh;tag=2c77312d397db3ac8ee9bc381884e5f418ce2438;nobranch=1"

