require freetype2.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/freetype2;protocol=ssh;tag=b91f3b65f17e59c4331f19be052056e06aa97a96;nobranch=1"

