require harfbuzz.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/harfbuzz;protocol=ssh;tag=58f0b94aebd4220cd073ec7931e2066baa9ba8d7;nobranch=1"

