require cairo.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/cairo;protocol=ssh;tag=3388424cbb6e054e4867e6fb0cc687a1a4c2bda2;nobranch=1"

