require psmisc.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/psmisc;protocol=ssh;tag=577433fdf2c69e451dcf18d871ca7596ce8a95ba;nobranch=1"

