require eina.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/eina;protocol=ssh;tag=3f86da98d10de2709e7273cd078c21318907163f;nobranch=1"

