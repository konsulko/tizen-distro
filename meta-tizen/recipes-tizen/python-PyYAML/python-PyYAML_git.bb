require python-PyYAML.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python-PyYAML;protocol=ssh;tag=a2dc4c5c085f50e51582945f8703aa495a981019;nobranch=1"

