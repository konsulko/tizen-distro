require kbd.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/kbd;protocol=ssh;tag=6061c1d7ebaa7698f68cf3fd945b4073e54759a0;nobranch=1"

