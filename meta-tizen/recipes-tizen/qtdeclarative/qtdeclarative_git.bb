require qtdeclarative.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/qtdeclarative;protocol=ssh;tag=7756204192459b0aece4e5104608f773b4b2d4da;nobranch=1"

