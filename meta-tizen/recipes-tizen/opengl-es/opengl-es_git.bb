require opengl-es.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/graphics/opengl-es;protocol=ssh;tag=ab24de8677671f27f52307248fb24ea4b105b1cb;nobranch=1"

