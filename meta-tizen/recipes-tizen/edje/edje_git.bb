require edje.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/edje;protocol=ssh;tag=a7d4e1ec6c0b973431b56b6a92bb960a2ee09693;nobranch=1"

