require yasm.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/yasm;protocol=ssh;tag=e5fa2a0d0f04a64bc0b2a04730bfde4f678040c6;nobranch=1"

