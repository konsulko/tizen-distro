require python-ZSI.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/python-ZSI;protocol=ssh;tag=bf2e35fcc66d2a80d50f505e123dc74b4893e3e3;nobranch=1"

