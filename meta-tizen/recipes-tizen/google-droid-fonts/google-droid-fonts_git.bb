require google-droid-fonts.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/google-droid-fonts;protocol=ssh;tag=39019d5e1ff564fb63ea9fbd1e40609efc9e9635;nobranch=1"

