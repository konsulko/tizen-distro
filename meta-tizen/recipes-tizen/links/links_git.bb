require links.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/links;protocol=ssh;tag=23d6c1572ece5bb74ba5d2ac27faa92df1d5d562;nobranch=1"

