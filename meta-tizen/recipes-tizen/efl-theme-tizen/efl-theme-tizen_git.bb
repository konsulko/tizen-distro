require efl-theme-tizen.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/profile/ivi/efl-theme-tizen;protocol=ssh;tag=7a2cff90629d6553db73175785be55476940fcf3;nobranch=1"

