require orc.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/orc;protocol=ssh;tag=5d5416310f19fa5a3307a110d4975e74f5690219;nobranch=1"

