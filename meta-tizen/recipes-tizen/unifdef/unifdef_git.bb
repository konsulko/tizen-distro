require unifdef.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/unifdef;protocol=ssh;tag=050339199b96abafacd26d52e95a4f41b381f029;nobranch=1"

