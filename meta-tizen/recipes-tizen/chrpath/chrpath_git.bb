require chrpath.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/chrpath;protocol=ssh;tag=f5746b20fc592f3fc31ded1d3ec617d04af95d42;nobranch=1"

