require re2c.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/re2c;protocol=ssh;tag=ece40865434f8e3663ddb52ee8b0bd1669d7695e;nobranch=1"

