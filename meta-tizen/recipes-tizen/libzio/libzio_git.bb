require libzio.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/libzio;protocol=ssh;tag=f750036332dc9311f2a4d207fcc238a7ca28edd1;nobranch=1"

