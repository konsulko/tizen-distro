require damageproto.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/upstream/damageproto;protocol=ssh;tag=b7578c9effd4ac538c57285b19276ac411d143d2;nobranch=1"

