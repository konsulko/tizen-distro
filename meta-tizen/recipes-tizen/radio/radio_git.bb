require radio.inc

PRIORITY = "10"

LIC_FILES_CHKSUM ??= "file://${COMMON_LICENSE_DIR}/GPL-2.0;md5=801f80980d171dd6425610833a22dbe6"

SRC_URI += "git://review.tizen.org/platform/core/api/radio;protocol=ssh;tag=4285844d4b16db4133ac99c1c44f92b6facd983e;nobranch=1"

